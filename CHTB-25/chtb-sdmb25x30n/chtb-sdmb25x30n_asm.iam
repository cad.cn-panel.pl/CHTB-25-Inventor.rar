# Autodesk Inventor assembly: chtb-sdmb25x30n_asm
Saved by Autodesk Inventor 2021.1 (Build 251245010, 245A)
## iProperties
Company: Microsoft
Created: 2018-05
Part Number: chtb-sdmb25x30n_asm
Description: STEP AP214
Document SubType Name: Assembly
Designer: user
Title: chtb-sdmb25x30n_asm.STEP
Author: Windows
Revision Number: ÈÎºÎ
Sending System: SolidWorks 2015
Preprocessor: SwSTEP 2.0
## Documents named in this file (4)
- D:\Vault_2016\Projekty\Clamptek\Hydraulic\CHTB\CHTB-25\Inventor\chtb-sdmb25x30n\chtb-sdmb25x30n_asm.iam
- D:\Vault_2016\Projekty\Clamptek\Hydraulic\CHTB\CHTB-25\Inventor\chtb-sdmb25x30n\CHTB-25QG.ipt
- D:\Vault_2016\Projekty\Clamptek\Hydraulic\CHTB\CHTB-25\Inventor\chtb-sdmb25x30n\CHTB-SDMB25X30NBT.ipt
- D:\Vault_2016\Projekty\Clamptek\Hydraulic\CHTB\CHTB-25\Inventor\chtb-sdmb25x30n\CHTB-SDMB25X30NHSG.ipt
## Components (3 placed, 3 different names)
1. CHTB-25QG_1
2. CHTB-SDMB25X30NBT_2
3. CHTB-SDMB25X30NHSG_3
